<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sample_net.ewp</path>
  </project>
  <batchBuild/>
</workspace>


