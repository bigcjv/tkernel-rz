# IAR project sample_net.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R8A77450 Renesas R8A77450
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 5
  ICCARM.CCDefines: UNDEF_KEEPALIVE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Kernel\Standard\inc; ..\..\..\..\..\..\Kernel\Standard\inc\CortexA; ..\..\..\..\..\..\Driver\Standard\inc; ..\..\..\..\..\..\Network\TCPIP\inc; ..\..\..\..\..\..\Network\NetApp; ..\..\..\..\..\..\Network\sample; ..\..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\src
  OBJCOPY.OOCOutputFile: sample_net.srec
  ILINK.IlinkOutputFile: sample_net.out
  ILINK.IlinkIcfFile: sample.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\Kernel\Standard\lib\CortexA\EWARM\v8\uC3cortexahl.a; ..\..\..\..\..\..\Network\TCPIP\lib\CortexA\EWARM\v8\uNet3cortexahl.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; UNDEF_KEEPALIVE
  ICCARM.CCOptLevel: 3
  group (top)
    ../../src/: cgi_sample.c exception.c ftp_server_cfg.c GL_kernel_id.c hw_init.c mmutbl_cfg.c net.c net_cfg.c sample.c sample_app.c shell_cfg.c
    ../../../../../../Network/sample/: ffsys.c shell.c
    ../../src/EWARM/: krn_mem.c prst.s79 vector.s79
  group Driver
    ../../../../../../Driver/Standard/src/: DDR_COM.c DDR_CortexA_GIC.c DDR_CortexA_GTIMER.c DDR_RZG1_SCIF.c
    ../../../../../../Driver/Standard/src/EWARM/: DDR_CortexA_GIC_sub.c DDR_CortexA_GTIMER_sub.c DDR_CortexA_MMU.s79
