# IAR project sample_uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R8A77450 Renesas R8A77450
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 0
  ICCARM.CCDefines: _AP_RZG0A_RZG1E_
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Kernel\mtkernel\include; ..\..\..\..\..\..\Kernel\mtkernel\config; ..\..\..\..\..\..\Kernel\mtkernel\kernel\knlinc; ..\..\..\..\..\..\Driver\Standard\inc; ..\..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\src
  OBJCOPY.OOCOutputFile: sample_uart.srec
  ILINK.IlinkOutputFile: sample_uart.out
  ILINK.IlinkIcfFile: sample.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; _AP_RZG0A_RZG1E_
  ICCARM.CCOptLevel: 3
  group Application
    ../../src/: mmutbl_cfg.c
  group micro T-Kernel Core
    ../../../../../../Kernel/mtkernel/kernel/sysinit/: sysinit.c
    ../../../../../../Kernel/mtkernel/kernel/inittask/: inittask.c
    ../../../../../../Kernel/mtkernel/kernel/usermain/: usermain.c
    ../../../../../../Kernel/mtkernel/kernel/tstdlib/: bitop.c string.c
    ../../../../../../Kernel/mtkernel/kernel/tkernel/: cpuctl.c device.c deviceio.c eventflag.c int.c klock.c mailbox.c memory.c mempfix.c mempool.c messagebuf.c misc_calls.c mutex.c objname.c power.c rendezvous.c semaphore.c task.c task_manage.c task_sync.c time_calls.c timer.c tkinit.c wait.c
    ../../../../../../Kernel/mtkernel/lib/libtk/: fastlock.c fastmlock.c kmalloc.c
    ../../../../../../Kernel/mtkernel/lib/libtm/: libtm.c libtm_printf.c
  group RZG1E Target
    ../../../../../../Kernel/mtkernel/kernel/sysdepend/ap_rzg0a_rzg1e/: cpu_clock.c devinit.c hw_setting.c power_save.c sys_start.c
    ../../../../../../Kernel/mtkernel/kernel/sysdepend/cpu/rzg1e/: interrupt.c
    ../../../../../../Kernel/mtkernel/lib/libtk/sysdepend/cpu/rzg1e/: int_rzg1e.c wusec_rzg1e.c
    ../../../../../../Kernel/mtkernel/lib/libtm/sysdepend/ap_rzg0a_rzg1e/: tm_com.c
  group ARMv7-A Core
    ../../../../../../Kernel/mtkernel/kernel/sysdepend/cpu/core/armv7a/: cpu_cntl.c exc_hdl.c
  group IAR Startup
    ../../../../../../Kernel/mtkernel/kernel/sysdepend/cpu/rzg1e/EWARM/: mtk_startup.s79 mtk_context.s79
    ../../../../../../Driver/Standard/src/EWARM/: DDR_CortexA_MMU.s79
